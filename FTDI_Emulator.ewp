# IAR project FTDI_Emulator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; STM32F10X_HD
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\c; $TOOLKIT_DIR$\CMSIS\Include; Source; Library\CMSIS; Library\USB; Library\SPL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F103xE
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Linker\stm32f10x_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  ICCARM.CCDefines: DEBUG; STM32F10X_MD
  ICCARM.CCOptLevel: 3
  AARM.ADefines: STM32F103xB
  OBJCOPY.OOCOutputFile: FTDI_Emulator.hex
  ILINK.IlinkIcfFile: Linker\stm32f10x_flash.icf
  group Library/CMSIS
    Library/CMSIS/: startup_stm32f10x.s stm32f10x.h stm32f10x_0.h stm32f10x_1.h stm32f10x_2.h stm32f10x_3.h stm32f10x_4.h system_stm32f10x.c system_stm32f10x.h
  group Library/SPL
    Library/SPL/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Library/USB
    Library/USB/: usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
  group Source
    Source/: assert.c assert.h EEPROM_Emulator.c EEPROM_Emulator.h fifo.c fifo.h FTDI_Bsp.c FTDI_Bsp.h FTDI_Descriptor.c FTDI_Descriptor.h FTDI_Eeprom.c FTDI_Eeprom.h FTDI_Emulator.c FTDI_Emulator.h FTDI_Type.h Global.h macro_misc.h main.c SEGGER_HardFault_Handler.c SEGGER_HardFaultHandler.S stm32_it.c stm32_it.h stm32f10x_conf.h stm32f10x_eeprom.c stm32f10x_eeprom.h system_stm32f10x.c trace.c trace.h usb_bsp.c usb_bsp.h usb_conf.h usb_istr.c usb_istr.h usb_pwr.c usb_pwr.h utility.c utility.h
